# Keil uVision project ProjectSTM32.uvprojx, settings and files
target UWBAnchor (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303C
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F303xC, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\Libraries\STM32F30x_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ../Libraries/CMSIS/Device/: system_stm32f30x.c startup_stm32f30x.s
  group Library
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_misc.c stm32f30x_syscfg.c stm32f30x_dma.c stm32f30x_rcc.c stm32f30x_adc.c stm32f30x_gpio.c stm32f30x_usart.c
    ../Program/: stm32f30x_conf.h
  group Driver
    ../Program/drivers/: stm32f3_delay.c stm32f3_adc.c stm32f3_usart.c
  group Program
    ../Program/: main.c uwbAnchor.c uwbAnchor_bsp.c uwbAnchor_it.c
  group Module
    ../Program/modules/: serial.c
  group Algorithm
    ../Program/algorithms/: string.c
